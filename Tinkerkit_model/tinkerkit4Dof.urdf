Commit message: Update urdf with 4 dof and model Braccio_trajectory_tracking

File: Tinkerkit_model/tinkerkit4Dof.urdf (robot description, URDF)
Before this commit: robot visual, 6 links, 5 joints
Links:
- removed link link5
Joints:
- removed joint wrist_roll
